# Keil uVision project cfc3.uvproj, settings and files
target Target 1 (MCS-51)
  device: W77E58 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x3FF) CLOCK(40000000)MODDP2
  output: cfc3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: a.C
